# Keil uVision project tinyUBOOT.uvprojx, settings and files
target tinyUBOOT (6190000::V6.19::ARMCLANG)
  device: STM32F405OEYx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: tinyUBOOT
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group boot
    ./boot/: bootm.c
  group include
    ./include/: bl.h bl_config.h boot_util.h bootm.h
  group main
    ./: main.c
